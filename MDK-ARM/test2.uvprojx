# Keil uVision project test2.uvprojx, settings and files
target test2 (ARM-ADS)
  device: STM32F429ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test2 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F439xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F4xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x68000000 size 0x186a0
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_ll_fmc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c
  group Application/User
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c dma.c usart.c spi.c fram.c sram.c AD7606_FSMC.c IIC.c delay.c timer.c led.c ds18b20.c sys.c adc.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f439xx.s
software components: CMSIS:CORE 5.0.0
